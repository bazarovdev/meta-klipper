# Add support to all USB to Serial converters
KERNEL_FEATURES:append = " features/usb/serial-all.scc"
