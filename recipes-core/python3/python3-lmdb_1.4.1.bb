SUMMARY = "Universal Python binding for the LMDB 'Lightning' Database"
HOMEPAGE = "https://pypi.org/project/lmdb/"

LICENSE = "OLDAP-2.8"
LIC_FILES_CHKSUM = "file://LICENSE;md5=153d07ef052c4a37a8fac23bc6031972"

SRC_URI[sha256sum] = "1f4c76af24e907593487c904ef5eba1993beb38ed385af82adb25a858f2d658d"

inherit pypi setuptools3
